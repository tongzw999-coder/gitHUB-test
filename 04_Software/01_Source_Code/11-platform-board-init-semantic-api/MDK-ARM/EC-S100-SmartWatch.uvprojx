# Keil uVision project EC-S100-SmartWatch.uvprojx, settings and files
target EC-S100-SmartWatch (5060960::V5.06 update 7 (build 960)::.\ARM-COMPLIER-506)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: EC-S100-SmartWatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../01_App/app_boot;../01_App/app_system;../02_Service/service_log;../02_Service/service_diagnosis;../03_Config;../03_Platform/platform_common;../03_Platform/platform_mcu;../03_Platform/platform_bsp;../04_Impl;../04_Impl/impl_board;../04_Impl/impl_mcu;../04_Impl/impl_service_port/log_port;../05_Vendor/SEGGER/RTT;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 01_App/app_boot
    ../01_App/app_boot/: app_boot.c app_boot.h
  group 01_App/app_system
    ../01_App/app_system/: app_system.c app_system.h
  group 02_Service/service_diagnosis
    ../02_Service/service_diagnosis/: service_diagnosis.c service_diagnosis.h
  group 02_Service/service_log
    ../02_Service/service_log/: service_log.c service_log.h
  group 03_Config
    ../03_Config/: version_config.h platform_mcu_config.h
  group 03_Platform/platform_common
    ../03_Platform/platform_common/: platform_object.c platform_device.c platform_service.c device_manager.c service_manager.c platform_version.c platform_type.h platform_error.h platform_def.h platform_lifecycle.h platform_object.h platform_device.h platform_service.h device_manager.h service_manager.h platform_version.h
  group 03_Platform/platform_mcu
    ../03_Platform/platform_mcu/: plat_irq.h plat_tick.h plat_gpio.h plat_uart.h
  group 03_Platform/platform_bsp
    ../03_Platform/platform_bsp/: board_init.h board_control.h
  group 04_Impl/impl_service_port/log_port
    ../04_Impl/impl_service_port/log_port/: log_port.c log_port.h
  group 04_Impl/impl_board
    ../04_Impl/impl_board/: board_init.c board_internal.h board_resource_config_ecs100.c board_resource_config.h board_control.c
  group 04_Impl/impl_mcu
    ../04_Impl/impl_mcu/: stm32f411_plat_irq.c stm32f411_plat_tick.c stm32f411_plat_gpio.c stm32f411_plat_uart.c
  group 05_Vendor/SEGGER_RTT
    ../05_Vendor/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
